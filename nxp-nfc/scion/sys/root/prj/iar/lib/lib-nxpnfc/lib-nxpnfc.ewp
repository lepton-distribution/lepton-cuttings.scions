# IAR project lib-nxpnfc.ewp, settings and files
configuration cortex-m4-debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG; RW_SUPPORT
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src; c:/tauon/sys/root/src/lib/lib-nxpnfc; c:/tauon/sys/root/src/lib/lib-nxpnfc/tool; c:/tauon/sys/root/src/lib/lib-nxpnfc/tml; c:/tauon/sys/root/src/lib/lib-nxpnfc/NfcLibrary/inc; c:/tauon/sys/root/src/lib/lib-nxpnfc/NfcLibrary/NdefLibrary/inc; c:/tauon/sys/root/src/lib/lib-nxpnfc/NfcLibrary/NxpNci/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib-nxpnfc.out
configuration cortex-m7-debug (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM7_430\Inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src; c:/tauon/sys/root/src/lib/lib-nxpnfc; c:/tauon/sys/root/src/lib/lib-nxpnfc/tool; c:/tauon/sys/root/src/lib/lib-nxpnfc/tml; c:/tauon/sys/root/src/lib/lib-nxpnfc/NfcLibrary/inc; c:/tauon/sys/root/src/lib/lib-nxpnfc/NfcLibrary/NdefLibrary/inc; c:/tauon/sys/root/src/lib/lib-nxpnfc/NfcLibrary/NxpNci/inc
  group lib/lib-nxpnfc
    ../../../../src/lib/lib-nxpnfc/: ndef_helper.c ndef_helper.h
  group lib/lib-nxpnfc/NfcLibrary/inc
    ../../../../src/lib/lib-nxpnfc/NfcLibrary/inc/: Nfc.h Nfc_settings.h
  group lib/lib-nxpnfc/NfcLibrary/NdefLibrary/inc
    ../../../../src/lib/lib-nxpnfc/NfcLibrary/NdefLibrary/inc/: P2P_NDEF.h RW_NDEF.h RW_NDEF_T1T.h RW_NDEF_T2T.h RW_NDEF_T3T.h RW_NDEF_T4T.h T4T_NDEF_emu.h
  group lib/lib-nxpnfc/NfcLibrary/NdefLibrary/src
    ../../../../src/lib/lib-nxpnfc/NfcLibrary/NdefLibrary/src/: P2P_NDEF.c RW_NDEF.c RW_NDEF_T1T.c RW_NDEF_T2T.c RW_NDEF_T3T.c RW_NDEF_T4T.c T4T_NDEF_emu.c
  group lib/lib-nxpnfc/NfcLibrary/NxpNci/inc
    ../../../../src/lib/lib-nxpnfc/NfcLibrary/NxpNci/inc/: NxpNci.h
  group lib/lib-nxpnfc/NfcLibrary/NxpNci/src
    ../../../../src/lib/lib-nxpnfc/NfcLibrary/NxpNci/src/: NxpNci.c
  group lib/lib-nxpnfc/tml
    ../../../../src/lib/lib-nxpnfc/tml/: tml.c tml.h
  group lib/lib-nxpnfc/tool
    ../../../../src/lib/lib-nxpnfc/tool/: tool.c tool.h
