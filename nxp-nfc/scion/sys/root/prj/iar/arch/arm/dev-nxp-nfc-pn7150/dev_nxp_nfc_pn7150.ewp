# IAR project dev_nxp_nfc_pn7150.ewp, settings and files
configuration cortex-m4-debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG; RW_SUPPORT
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/tool; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/tml; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/NfcLibrary/inc; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/NfcLibrary/NdefLibrary/inc; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/NfcLibrary/NxpNci/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dev_nxp_nfc_pn7150.out
configuration cortex-m7-debug (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: _SAMV71Q21__; BOARD_SAMV71_XULT; MPU_HAS_NOCACHE_REGION; sram; TRACE_LEVEL=0; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG; RW_SUPPORT
  ICCARM.CCIncludePath2: C:\tauon\sys\root\src\kernel\core\ucore\embOSCXM7_430\Inc; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM7/r0p1; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/tool; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/tml; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/NfcLibrary/inc; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/NfcLibrary/NdefLibrary/inc; c:/tauon/sys/root/src/kernel/dev/arch/all/i2c/nxp-nfc/NfcLibrary/NxpNci/inc
  group kernel/dev/arch/all/i2c/nxp-nfc/pn7150
    ../../../../../src/kernel/dev/arch/all/i2c/nxp-nfc/pn7150/: dev_nxp_nfc_pn7150_x.c dev_nxp_nfc_pn7150_x.h
