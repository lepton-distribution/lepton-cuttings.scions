<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>kernel</name>
    <group>
      <name>core</name>
      <group>
        <name>usb</name>
        <group>
          <name>stm32_usb_core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\core\usb\stm32_usb_core\usb_core_audio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\core\usb\stm32_usb_core\usb_core_audio.h</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>usb</name>
      <group>
        <name>stm32f4-usb-core</name>
        <group>
          <name>core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usb_device.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usb_device.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usbd_audio_if.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usbd_audio_if.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usbd_conf.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usbd_conf.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usbd_desc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\core\usbd_desc.h</name>
          </file>
        </group>
        <group>
          <name>stm32_usb_device_library</name>
          <group>
            <name>class</name>
            <group>
              <name>audio</name>
              <group>
                <name>inc</name>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Inc\usbd_audio.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Inc\usbd_audio_core.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Inc\usbd_audio_if_template.h</name>
                </file>
              </group>
              <group>
                <name>src</name>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Src\usbd_audio-donotdiffused.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Src\usbd_audio.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Src\usbd_audio_core.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Class\AUDIO\Src\usbd_audio_if_template.c</name>
                </file>
              </group>
            </group>
          </group>
          <group>
            <name>core</name>
            <group>
              <name>inc</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Inc\usbd_core.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Inc\usbd_ctlreq.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Inc\usbd_def.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Inc\usbd_ioreq.h</name>
              </file>
            </group>
            <group>
              <name>src</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Src\usbd_core.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Src\usbd_ctlreq.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\src\kernel\usb\stm32f4-usb-core\stm32_usb_device_library\Core\Src\usbd_ioreq.c</name>
              </file>
            </group>
          </group>
        </group>
      </group>
    </group>
  </group>
</project>


